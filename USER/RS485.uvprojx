# Keil uVision project RS485.uvprojx, settings and files
target RS485 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RS485 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\RS485;..\HARDWARE\MODBUS;..\HARDWARE\EC20;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\protocol;..\HARDWARE\flash;..\HARDWARE\queue;..\HARDWARE\MALLOC;..\HARDWARE\SD
  memory RVCT4: ROM 0x8040000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_sdio.c
    ../FWLIB/inc/: stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_rtc.h stm32f4xx_pwr.h stm32f4xx_dma.h stm32f4xx_sdio.h
software components: CMSIS:CORE 5.0.1
